<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amb_phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>npsk-1</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>amb_swap</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>cons</value></param>
<param><key>type</key><value>qpsk</value></param>
<param><key>precision</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dpsk</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>npsk</value></param>
<param><key>value</key><value>cons.arity()</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oqpsk</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>1.4e9</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>70e6</value></param>
<param><key>step</key><value>1e2</value></param>
<param><key>stop</key><value>6e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>min_len</key><value>400</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>72</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>sym_rate*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sym_rate</value></param>
<param><key>value</key><value>20000e3</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>2</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>alpha</key><value>1e-4</value></param>
<param><key>msg_nsamples</key><value>int(sym_rate)</value></param>
<param><key>type</key><value>2</value></param>
</block>
<block>
<key>fastpsk_agc</key>
<param><key>id</key><value>fastpsk_agc_0</value></param>
<param><key>max_gain</key><value>65535</value></param>
<param><key>minoutbuf</key><value>32</value></param>
<param><key>n</key><value>n</value></param>
<param><key>rate</key><value>1e-5</value></param>
<param><key>ref</key><value>8192*1.4</value></param>
</block>
<block>
<key>fastpsk_bert_sink</key>
<param><key>id</key><value>fastpsk_bert_sink_0</value></param>
<param><key>order</key><value>9</value></param>
</block>
<block>
<key>fastpsk_costas</key>
<param><key>id</key><value>fastpsk_costas_0</value></param>
<param><key>loop_bw</key><value>3e-3</value></param>
<param><key>max_deviation</key><value>math.pi/4/n</value></param>
<param><key>minoutbuf</key><value>32</value></param>
<param><key>n</key><value>n</value></param>
<param><key>order</key><value>npsk</value></param>
</block>
<block>
<key>fastpsk_deambiguity</key>
<param><key>id</key><value>fastpsk_deambiguity_0</value></param>
<param><key>diff</key><value>bool(dpsk)</value></param>
<param><key>npsk</key><value>npsk</value></param>
<param><key>phase</key><value>amb_phase</value></param>
<param><key>swap</key><value>amb_swap</value></param>
</block>
<block>
<key>fastpsk_fir_filter_ssf</key>
<param><key>id</key><value>fastpsk_fir_filter_ssf_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>numpy.ones(sps)/sps</value></param>
</block>
<block>
<key>fastpsk_mm_crec</key>
<param><key>id</key><value>fastpsk_mm_crec_0</value></param>
<param><key>loop_bw</key><value>1e-2</value></param>
<param><key>max_deviation</key><value>0.1</value></param>
<param><key>minoutbuf</key><value>32</value></param>
<param><key>n</key><value>n</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>fastpsk_npsk_slicer</key>
<param><key>id</key><value>fastpsk_npsk_slicer_0</value></param>
<param><key>gray</key><value>False</value></param>
<param><key>npsk</key><value>npsk</value></param>
</block>
<block>
<key>fastpsk_qdelay</key>
<param><key>id</key><value>fastpsk_qdelay_0</value></param>
<param><key>delay</key><value>-sps/2*oqpsk</value></param>
</block>
<block>
<key>fastpsk_sc16_to_cf32</key>
<param><key>id</key><value>fastpsk_sc16_to_cf32_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>8192</value></param>
</block>
<block>
<key>fastpsk_sc16_to_cf32</key>
<param><key>id</key><value>fastpsk_sc16_to_cf32_1</value></param>
<param><key>scale</key><value>8192</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>kcsa_power_sensor</key>
<param><key>id</key><value>kcsa_power_sensor_0</value></param>
<param><key>cal</key><value>0</value></param>
<param><key>decim</key><value>32768</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-70</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0_0</value></param>
<param><key>average</key><value>0.2</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>0</value></param>
<param><key>ymin</key><value>-60</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>avg</key><value>1e-6</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>max</key><value>60</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>2,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>4,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*8</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Phase Err</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024*8</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Timing Err</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>128</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>Timing Err</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>rx_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>minoutbuf</key><value>32</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fastpsk_agc_0</source_block_id><sink_block_id>fastpsk_costas_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_bert_sink_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>ber</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>fastpsk_costas_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_costas_0</source_block_id><sink_block_id>fastpsk_qdelay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_deambiguity_0</source_block_id><sink_block_id>fastpsk_npsk_slicer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_fir_filter_ssf_0</source_block_id><sink_block_id>fastpsk_mm_crec_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_mm_crec_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_mm_crec_0</source_block_id><sink_block_id>fastpsk_deambiguity_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_mm_crec_0</source_block_id><sink_block_id>fastpsk_sc16_to_cf32_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_npsk_slicer_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_npsk_slicer_0</source_block_id><sink_block_id>fastpsk_bert_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_qdelay_0</source_block_id><sink_block_id>fastpsk_fir_filter_ssf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_0</source_block_id><sink_block_id>kcsa_power_sensor_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_1</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_1</source_block_id><sink_block_id>qtgui_const_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_1</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fastpsk_sc16_to_cf32_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>kcsa_power_sensor_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fastpsk_agc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>fastpsk_sc16_to_cf32_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
